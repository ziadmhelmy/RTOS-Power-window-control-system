# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c tm4c123gh6pm.h hw_memmap.h hw_sysctl.h bitwise_operation.h DIO.h types.h
    ../semester 8/RTOS/inc/: hw_ints.h
    C:/Users/ZIAD/Desktop/RTOS Project/RTOS Project/: DIO.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
